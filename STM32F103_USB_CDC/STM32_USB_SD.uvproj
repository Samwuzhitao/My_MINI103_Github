# Keil uVision project STM32_USB_SD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_USB_SD
  c flags: Optim=1
  c include: .\cmsicore;.\cmsisboot;.\HardWare;.\STM32F10x_StdPeriph_Driver\inc;.\STM32_USB-FS-Device_Driver\inc;.\USB_App;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group cmsiscore
    ./cmsicore/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group cmsisboot
    ./cmsisboot/: system_stm32f10x.c
  group HardWare
    ./HardWare/: LED.c Uart.c SD.c
  group STDLIB
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USBLIB
    ./STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBApp
    ./USB_App/: fsmc_nand.c hw_config.c mass_mal.c memory.c nand_if.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group User
    ./User/: main.c stm32_it.c
