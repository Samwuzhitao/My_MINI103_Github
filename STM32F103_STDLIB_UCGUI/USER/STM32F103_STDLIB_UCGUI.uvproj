# Keil uVision project STM32F103_STDLIB_UCGUI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_STDLIB_NET
  c flags: Optim=1
  c include: ..\CMSIS\CoreSupport;..\CMSIS\STM32F10x;..\HARDWARE\ENC28J60;..\HARDWARE\FSMC;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SD;..\HARDWARE\SPI;..\HARDWARE\TFT;..\HARDWARE\TOUCH;..\HARDWARE\usart;..\STM32F10x_StdPeriph_Driver\inc;..\USER;..\HARDWARE\SYSTICK;..\STemWin\Demo;..\STemWin\Config;..\STemWin\inc;..\STemWin\OS;..\STemWin\Lib;.\My_GUI;.\My_Board_BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS_CORE
    ../CMSIS/CoreSupport/: core_cm3.c core_cm3.h
  group Startup
    ./: startup_stm32f10x_hd.s
  group MSIS_BOOT
    ../CMSIS/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group My_Board_BSP
    ./My_Board_BSP/: MyBoard_BSP.c MyBoard_BSP.h
  group Std_Lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group HardWare
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FSMC/: FSMC.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TFT/: TFT_driver.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/usart/: Com.c
    ../HARDWARE/SD/: mmcbb.c
  group StemWin_Config
    ../STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../STemWin/OS/: GUI_X.c
    ./: GUI_X_TOUCH.c
  group StemWin_Lib
    ../STemWin/Lib/: STemWin522_CM3_Keil.lib
  group MyGUI
    ./My_GUI/: My_GUI_Main.c
  group USER
    ./: main.c stm32f10x_conf.h stm32f10x_it.c
