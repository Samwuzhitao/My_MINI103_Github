# Keil uVision project STM32F207_STD_USB_HID.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F207_STD_USB_HID
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: .\cmsisboot;.\cmsiscore;.\STM32F2xx_StdPeriph_Driver\inc;.\STM32_USB_Device_Library\Class\hid\inc;.\STM32_USB_Device_Library\Core\inc;.\User;.\Components;.\STM32_USB_OTG_Driver\inc;.\CMSIS_DAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group cmsiscore
    ./cmsiscore/: core_cm3.c core_cm3.h
  group cmsisboot
    ./cmsisboot/: startup_stm32f2xx.s stm32f2xx.h system_stm32f2xx.c system_stm32f2xx.h
  group cmsisdap
    ./CMSIS_DAP/: DAP.c DAP.h DAP_config.h JTAG_DP.c SW_DP.c
  group Component
    ./Components/: lcd_log.c stm32_eval.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c
  group STM32F2xx_StdPeriph_Driver
    ./STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group STM32_USB_Device_Library
    ./STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group STM32_USB_OTG_Driver
    ./STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ./User/: app.c stm32fxxx_it.c usb_bsp.c usbd_desc.c usbd_usr.c
