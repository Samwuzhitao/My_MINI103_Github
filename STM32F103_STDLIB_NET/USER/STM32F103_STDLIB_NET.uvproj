# Keil uVision project STM32F103_STDLIB_NET.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_STDLIB_NET
  c flags: Optim=1
  c include: ..\CMSIS\CoreSupport;..\CMSIS\STM32F10x;..\HARDWARE\ENC28J60;..\HARDWARE\FSMC;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SD;..\HARDWARE\SPI;..\HARDWARE\TFT;..\HARDWARE\TOUCH;..\HARDWARE\usart;..\STM32F10x_StdPeriph_Driver\inc;..\USER;..\HARDWARE\SYSTICK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_hd.s
  group cmsiscore
    ../CMSIS/CoreSupport/: core_cm3.c core_cm3.h
  group cmsisboot
    ../CMSIS/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group stdlib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group hardware
    ../HARDWARE/FSMC/: FSMC.c FSMC.h
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/TFT/: 8x8.h 8x16.h 16x16.h 16x32.h 30x60.h bkg.h pic.h TFT_driver.c TFT_driver.h
    ../HARDWARE/TOUCH/: touch.c touch.h
    ../HARDWARE/usart/: Com.c COM.H
    ../HARDWARE/SD/: diskio.h integer.h mmcbb.c
  group user
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group ENC18J60
    ../HARDWARE/SPI/: spi.h spi.c
    ../HARDWARE/ENC28J60/: ENC28J60.c ENC28J60.h ENC28J60_Config.h Hw_ENC28J60.h
