# IAR project Contiki_STM32F103_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\CMSIS\CM3\CoreSupport; ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\STM32F10x_StdPeriph_Driver\inc; ..\USER; ..\Contiki\core; ..\Contiki\core\sys; ..\Contiki\core\lib; ..\Contiki\CPU
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Contiki_STM32F103_Test.hex
  ILINK.IlinkOutputFile: Contiki_STM32F103_Test.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Contiki
    ../Contiki/core/: contiki-lib.h contiki-net.h contiki-version.h contiki.h
  group Contiki/Core/sys
    ../Contiki/core/sys/: autostart.c etimer.c process.c procinit.c timer.c
  group Contiki/CPU
    ../Contiki/CPU/: clock.c debug-uart.c
  group platform/CMSIS_Boot
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group platform/CMSIS_Boot/Startup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group platform/CMSIS_Core
    ../CMSIS/CM3/CoreSupport/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group platform/STM32F10x_StdPeriph_Driver/inc
    ../STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group platform/STM32F10x_StdPeriph_Driver/src
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group platform/USER
    ../USER/: contiki-conf.h contiki-main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
