# Keil uVision project STM32_USB_Demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32_USB_Demo
  c flags: Optim=4 OneElfS=1
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL,USE_USB_FS,USE_ULPI_PHY
  c include: .\cmsisboot;.\cmsiscore;.\Components;.\Components\stmpe811;.\My_HardWare;.\STM32F2xx_HAL_Driver\Inc;.\STM32_USB_Device_Library\Core\Inc;.\STM32_USB_Device_Library\Class\CDC\Inc;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group cmsisboot
    ./cmsisboot/: startup_stm32f207xx.s stm32f2xx.h stm32f207xx.h system_stm32f2xx.c system_stm32f2xx.h
  group cmsiscore
    ./cmsiscore/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group Components
    ./Components/: stm322xg_eval.c stm322xg_eval_io.c
    ./Components/stmpe811/: stmpe811.c
  group USB_Device_Library
    ./STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group HAL_Driver
    ./STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_irda.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_msp_template.c stm32f2xx_hal_nand.c stm32f2xx_hal_nor.c stm32f2xx_hal_pccard.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_usb.c
  group My_HardWare
    ./My_HardWare/: Uart.c
  group User
    ./User/: main.c stm32f2xx_hal_msp.c stm32f2xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
